# Keil uVision project STM32-DEMO.uvproj, settings and files
target TIM3-DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c PWM.c Play.c Time_test.c can.c usart.c ISDebug.c util.c SysTick.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
